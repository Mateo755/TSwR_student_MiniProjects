Commit message: Task 1 finished
Polynomial trajectory generator implemented and some corrections in FLC class

File: urdf/planar2dof.urdf (robot description, URDF)
Before this commit: robot planar2dof, 5 links, 4 joints
Links:
- link planar2dof/link_striker_ee: mass 0 -> 3.0
